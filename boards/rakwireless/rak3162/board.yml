## boards/rakwireless/rak3162/board.yml
```yaml
board:
  name: rak3162
  full_name: RAK3162
  vendor: rakwireless
  socs:
  - name: nrf54l15
```
